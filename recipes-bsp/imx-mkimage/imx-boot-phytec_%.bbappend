FILESEXTRAPATHS:prepend := "${TOPDIR}/../repos/meta-freescale/recipes-bsp/imx-mkimage/files:"
FILESEXTRAPATHS:prepend := "${TOPDIR}/../repos/meta-imx/meta-imx-bsp/recipes-bsp/imx-mkimage/files:"