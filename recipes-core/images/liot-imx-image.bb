require recipes-core/images/phytec-headless-image.bb

DESCRIPTION = "L.IOT headles image with RAUC and snapd integration"

IMAGE_FSTYPES += "partup"
