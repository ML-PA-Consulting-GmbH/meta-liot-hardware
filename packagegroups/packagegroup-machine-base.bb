RDEPENDS:${PN}:remove = "firmware-nxp-wifi-nxpiw612-sdio"