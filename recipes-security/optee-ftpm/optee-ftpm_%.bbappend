COMPATIBLE_MACHINE:edge-imx93-segin = "edge-imx93-segin"